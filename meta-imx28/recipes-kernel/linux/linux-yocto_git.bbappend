SRC_URI = "file:///opt/downloads/kernel-orgi/linux-yocto-2.6.37"
